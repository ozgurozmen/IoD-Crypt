# IAR project microFourQ_AVR.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0xA0
  General.SCCStackSize: 0x32
  General.SCRStackSize: 64
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m2560 ATmega2560
  ICCAVR.CCDefines: __IAR__; _AVR_; _ASM_; USE_ENDO; _NO_CACHE_MEM_
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 2
  ICCAVR.CCOptLevel: 2
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm2560.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  group (top)
    ../src/: crypto_util.c Dronecrypt.c Dronecrypt.h Dronecrypt_Tables.h eccp2.c eccp2_no_endo.c FourQ.h FourQ_api.h FourQ_internal.h FourQ_params.h FourQ_tables.h IAR_stdint.h kex.c main.c schnorrq.c table_lookup.h
  group AVR
    ../src/AVR/: fp.h fpadd1271.s fpcopy1271.s fpcopy1271_flash.s fpneg1271.s fpsub1271.s fpzero1271.s mod1271.s mod_mul128.S mod_mul_dbl128.S mod_sqr128.S mp_add.s mp_sub.s mul256.S mul32.S mul64.S
  group blake2b
    ../src/blake2b/: blake.c blake.h sph_blake.h sph_types.h
  group random
    ../src/random/: random.c random.h
  group tests
    ../src/tests/: crypto_tests.c dronecrypt_tests.c ecc_tests.c fp_tests.c test_extras.c test_extras.h
